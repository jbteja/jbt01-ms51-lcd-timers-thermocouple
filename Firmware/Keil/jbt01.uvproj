# Keil uVision project jbt01.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: jbt01 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\Objects\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\MS51\MS51FB\Library\Device\Include;D:\MS51\MS51FB\Library\StdDriver\inc;..\..\Firmware
  link misc: REMOVEUNUSED
  group StartUp
    ../: STARTUP.A51
  group Include
    ../: global.h lcd.h max6675.h
  group Source
    D:/MS51/MS51FB/Library/StdDriver/src/: sys.c common.c spi.c
    ../: global.c lcd.c max6675.c main.c
